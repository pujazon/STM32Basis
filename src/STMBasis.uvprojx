# Keil uVision project STMBasis.uvprojx, settings and files
target STM32 How to (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: img_stm32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group DrvGPIO
    ./DrvGPIO/: api_gpio.c gpio.c utils_gpio.c api_gpio.h gpio.h utils_gpio.h
  group ModesStates
    ./ModesStates/: state_snippet.c ModeState_ISR.s state_snippet.h
  group SLib
    ./SLib/: slib.c slib.h
  group Main
    ./: main.c Startup.c Startup.s
software components: CMSIS:CORE 5.0.2
